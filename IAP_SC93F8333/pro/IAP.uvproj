# Keil uVision project IAP.uvproj, settings and files
target IAP (MCS-51)
  device: SC93F8333 SC93Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF)  XRAM(0-0x3FF) CLOCK(24000000)
  output: IAP +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp;..\lib;..\TimeOut;..\user
  group startup
    ./: STARTUP.A51
  group user
    ../user/: main.c system.c
  group lib
    ../lib/: SC93F833x_C.H
  group bsp
    ../bsp/: bsp_led.c eeprom.c
  group TimeOut
    ../TimeOut/: TimeOut.c
